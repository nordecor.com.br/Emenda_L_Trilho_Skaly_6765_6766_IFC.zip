Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-31T17:29:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 31 17:29:38 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\65571b83-0216-4fe3-89b4-050b4061fda0\0a29932c-4295-482e-b556-05f2c10eb17d\ifc * Database version: 5507 * Database creation date: Mon Mar 31 17:29:36 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 31 17:29:37 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 31 17:29:37 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6766, Emenda_L_Trilho_Skaly_6765_6766_Nordecor:6766:328215
In: Nível 1
Type - Material: Metal - Alumínio - Preto
Type - Cotas - Comprimento 01: 114.5 mm; Comprimento 02: 114.4 mm
Type - Dados - Data de atualização: 31/03/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda “L” de sobrepor para trilho SKALY acabamento branco; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6766; Nome do tipo: 6766; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6766.png; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/emenda-l-de-sobrepor-p-trilho-skaly/
Type - Gráficos - Simbologia: Imagem raster: 6766 2D.png
Type - Materiais e acabamentos - Emenda "I": Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Emenda_L_Trilho_Skaly_6765_6766_Nordecor; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.00703544 m2; Volume: 0.0000286329 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Emenda_L_Trilho_Skaly_6765_6766_Nordecor: 6766; Família e tipo: Emenda_L_Trilho_Skaly_6765_6766_Nordecor: 6766; ID de tipo: Emenda_L_Trilho_Skaly_6765_6766_Nordecor: 6766; Tipo: Emenda_L_Trilho_Skaly_6765_6766_Nordecor: 6766
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
